.title KiCad schematic
J1 NC_01 NC_02 NC_03 NC_04 /DATA0 NC_05 /DATA1 NC_06 /DATA2 NC_07 NC_08 GND /DATA3 NC_09 /DATA4 NC_10 /DATA5 NC_11 /CLKIN NC_12 NC_13 NC_14 /DATA6 NC_15 /DATA7 NC_16 /DATA8 NC_17 +3V3 GND /DATA9 NC_18 /DATA10 NC_19 /DATA11 NC_20 /DATA12 NC_21 /DATA13 NC_22 CON40A
C1 +3V3 GND 100n
U1 GND /CLKIN /CLK4 /CLKIN /CLK5 /CLKIN /CLK6 /CLKIN NC_23 GND /CLKIN /CLK3 /CLKIN /CLK2 /CLKIN /CLK1 /CLKIN /CLK0 GND +3V3 74AHC244
C2 +3V3 GND 100u
C3 +3V3 GND 100u
C4 +3V3 GND 100u
C5 +3V3 GND 100u
C7 +3V3 GND 0.1u
U3 +3V3 +3V3 /CLK0 Net-_R2-Pad2_ GND MIC
C6 +3V3 GND 0.1u
U2 +3V3 GND /CLK0 Net-_R1-Pad2_ GND MIC
R1 /DATA0 Net-_R1-Pad2_ 130
R2 /DATA0 Net-_R2-Pad2_ 130
C9 +3V3 GND 0.1u
U5 +3V3 +3V3 /CLK0 Net-_R4-Pad2_ GND MIC
C8 +3V3 GND 0.1u
U4 +3V3 GND /CLK0 Net-_R3-Pad2_ GND MIC
R3 /DATA1 Net-_R3-Pad2_ 130
R4 /DATA1 Net-_R4-Pad2_ 130
C11 +3V3 GND 0.1u
U7 +3V3 +3V3 /CLK1 Net-_R6-Pad2_ GND MIC
C10 +3V3 GND 0.1u
U6 +3V3 GND /CLK1 Net-_R5-Pad2_ GND MIC
R5 /DATA2 Net-_R5-Pad2_ 130
R6 /DATA2 Net-_R6-Pad2_ 130
C13 +3V3 GND 0.1u
U9 +3V3 +3V3 /CLK1 Net-_R8-Pad2_ GND MIC
C12 +3V3 GND 0.1u
U8 +3V3 GND /CLK1 Net-_R7-Pad2_ GND MIC
R7 /DATA3 Net-_R7-Pad2_ 130
R8 /DATA3 Net-_R8-Pad2_ 130
C15 +3V3 GND 0.1u
U11 +3V3 +3V3 /CLK2 Net-_R10-Pad2_ GND MIC
C14 +3V3 GND 0.1u
U10 +3V3 GND /CLK2 Net-_R9-Pad2_ GND MIC
R9 /DATA4 Net-_R9-Pad2_ 130
R10 /DATA4 Net-_R10-Pad2_ 130
C17 +3V3 GND 0.1u
U13 +3V3 +3V3 /CLK2 Net-_R12-Pad2_ GND MIC
C16 +3V3 GND 0.1u
U12 +3V3 GND /CLK2 Net-_R11-Pad2_ GND MIC
R11 /DATA5 Net-_R11-Pad2_ 130
R12 /DATA5 Net-_R12-Pad2_ 130
C19 +3V3 GND 0.1u
U15 +3V3 +3V3 /CLK3 Net-_R14-Pad2_ GND MIC
C18 +3V3 GND 0.1u
U14 +3V3 GND /CLK3 Net-_R13-Pad2_ GND MIC
R13 /DATA6 Net-_R13-Pad2_ 130
R14 /DATA6 Net-_R14-Pad2_ 130
C21 +3V3 GND 0.1u
U17 +3V3 +3V3 /CLK3 Net-_R16-Pad2_ GND MIC
C20 +3V3 GND 0.1u
U16 +3V3 GND /CLK3 Net-_R15-Pad2_ GND MIC
R15 /DATA7 Net-_R15-Pad2_ 130
R16 /DATA7 Net-_R16-Pad2_ 130
C23 +3V3 GND 0.1u
U19 +3V3 +3V3 /CLK4 Net-_R18-Pad2_ GND MIC
C22 +3V3 GND 0.1u
U18 +3V3 GND /CLK4 Net-_R17-Pad2_ GND MIC
R17 /DATA8 Net-_R17-Pad2_ 130
R18 /DATA8 Net-_R18-Pad2_ 130
C25 +3V3 GND 0.1u
U21 +3V3 +3V3 /CLK4 Net-_R20-Pad2_ GND MIC
C24 +3V3 GND 0.1u
U20 +3V3 GND /CLK4 Net-_R19-Pad2_ GND MIC
R19 /DATA9 Net-_R19-Pad2_ 130
R20 /DATA9 Net-_R20-Pad2_ 130
C27 +3V3 GND 0.1u
U23 +3V3 +3V3 /CLK5 Net-_R22-Pad2_ GND MIC
C26 +3V3 GND 0.1u
U22 +3V3 GND /CLK5 Net-_R21-Pad2_ GND MIC
R21 /DATA10 Net-_R21-Pad2_ 130
R22 /DATA10 Net-_R22-Pad2_ 130
C29 +3V3 GND 0.1u
U25 +3V3 +3V3 /CLK5 Net-_R24-Pad2_ GND MIC
C28 +3V3 GND 0.1u
U24 +3V3 GND /CLK5 Net-_R23-Pad2_ GND MIC
R23 /DATA11 Net-_R23-Pad2_ 130
R24 /DATA11 Net-_R24-Pad2_ 130
C31 +3V3 GND 0.1u
U27 +3V3 +3V3 /CLK6 Net-_R26-Pad2_ GND MIC
C30 +3V3 GND 0.1u
U26 +3V3 GND /CLK6 Net-_R25-Pad2_ GND MIC
R25 /DATA12 Net-_R25-Pad2_ 130
R26 /DATA12 Net-_R26-Pad2_ 130
C33 +3V3 GND 0.1u
U29 +3V3 +3V3 /CLK6 Net-_R28-Pad2_ GND MIC
C32 +3V3 GND 0.1u
U28 +3V3 GND /CLK6 Net-_R27-Pad2_ GND MIC
R27 /DATA13 Net-_R27-Pad2_ 130
R28 /DATA13 Net-_R28-Pad2_ 130
.end
